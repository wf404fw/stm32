# Keil uVision project wf.uvprojx, settings and files
target template (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: wf +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\core;..\user;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\headware\beep;..\headware\led;..\headware\key;..\headware\motor;..\headware\TIM_INT;..\headware\control;..\headware\oled;..\headware\MPU6050;..\headware\IIC;..\headware\DMP;..\headware\DataScope_DP;..\headware\show
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group core
    ../core/: core_cm3.c startup_stm32f10x_hd.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group headware
    ../headware/beep/: beep.c
    ../headware/led/: led.c
    ../headware/key/: key.c
    ../headware/motor/: motor.c
    ../headware/TIM_INT/: TIM_INT.c
    ../headware/control/: control.c
    ../headware/oled/: oled.c
    ../headware/IIC/: IOI2C.c
    ../headware/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../headware/MPU6050/: MPU6050.c
    ../headware/DataScope_DP/: DataScope_DP.c
    ../headware/show/: show.c
